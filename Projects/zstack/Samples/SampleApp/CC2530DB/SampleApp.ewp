# IAR project SampleApp.ewp, settings and files
configuration CoordinatorEB (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\Chipcon\CC2530.i51
  ICC8051.CCDefines: ZTOOL_P1; MT_TASK; MT_SYS_FUNC; MT_ZDO_FUNC; LCD_SUPPORTED=DEBUG
  ICC8051.CCDiagSuppress: Pe001,Pa010
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\SOURCE; ..\..\..\ZMAIN\TI2530DB; ..\..\..\..\..\COMPONENTS\MT; ..\..\..\..\..\COMPONENTS\HAL\INCLUDE; ..\..\..\..\..\COMPONENTS\HAL\TARGET\CC2530EB; ..\..\..\..\..\COMPONENTS\OSAL\MCU\CCSOC; ..\..\..\..\..\COMPONENTS\OSAL\INCLUDE; ..\..\..\..\..\COMPONENTS\STACK\AF; ..\..\..\..\..\COMPONENTS\STACK\NWK; ..\..\..\..\..\COMPONENTS\STACK\SEC; ..\..\..\..\..\COMPONENTS\STACK\SAPI; ..\..\..\..\..\COMPONENTS\STACK\SYS; ..\..\..\..\..\COMPONENTS\STACK\ZDO; ..\..\..\..\..\COMPONENTS\ZMAC\F8W; ..\..\..\..\..\COMPONENTS\ZMAC; ..\..\..\..\..\COMPONENTS\SERVICES\SADDR; ..\..\..\..\..\COMPONENTS\SERVICES\SDATA; ..\..\..\..\..\COMPONENTS\MAC\INCLUDE; ..\..\..\..\..\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\srf04; ..\..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\srf04\SINGLE_CHIP
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\..\Tools\CC2530DB\f8w2530.xcl
configuration RouterEB (8051, debug)
  as the first configuration, except:
configuration EndDeviceEB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: NWK_AUTO_POLL; ZTOOL_P1; MT_TASK; MT_SYS_FUNC; MT_ZDO_FUNC; LCD_SUPPORTED=DEBUG
configuration DemoEB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: BUILD_ALL_DEVICES; HOLD_AUTO_START; LCD_SUPPORTED; HAL_UART=FALSE
configuration CoordinatorEB-Pro (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: ZIGBEEPRO; HAL_UART=TRUE; HOLD_AUTO_START; NV_RESTORE; ZCL_IDENTIFY; ZCL_ON_OFF; ZCL_READ; ZCL_WRITE; xHAL_DMA=FALSE; xHAL_UART_DMA=FALSE; xZTOOL_P1; xMT_TASK; xMT_SYS_FUNC; xMT_ZDO_FUNC; xLCD_SUPPORTED=DEBUG
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\SOURCE; ..\..\..\ZMAIN\TI2530DB; ..\..\..\..\..\COMPONENTS\MT; ..\..\..\..\..\COMPONENTS\HAL\INCLUDE; ..\..\..\..\..\COMPONENTS\HAL\TARGET\CC2530EB; ..\..\..\..\..\COMPONENTS\OSAL\MCU\CCSOC; ..\..\..\..\..\COMPONENTS\OSAL\INCLUDE; ..\..\..\..\..\COMPONENTS\STACK\AF; ..\..\..\..\..\COMPONENTS\STACK\NWK; ..\..\..\..\..\COMPONENTS\STACK\SEC; ..\..\..\..\..\COMPONENTS\STACK\SAPI; ..\..\..\..\..\COMPONENTS\STACK\SYS; ..\..\..\..\..\COMPONENTS\STACK\ZDO; ..\..\..\..\..\COMPONENTS\STACK\ZCL; ..\..\..\..\..\COMPONENTS\ZMAC\F8W; ..\..\..\..\..\COMPONENTS\ZMAC; ..\..\..\..\..\COMPONENTS\SERVICES\SADDR; ..\..\..\..\..\COMPONENTS\SERVICES\SDATA; ..\..\..\..\..\COMPONENTS\MAC\INCLUDE; ..\..\..\..\..\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\srf04; ..\..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\srf04\SINGLE_CHIP
configuration RouterEB-Pro (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: as above
  ICC8051.CCIncludePath2: as above
configuration EndDeviceEB-Pro (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: ZIGBEEPRO; NWK_AUTO_POLL; HAL_UART=TRUE; HOLD_AUTO_START; NV_RESTORE; xHAL_UART_ISR_TX_MAX=200; xPOWER_SAVING; ZCL_READ; ZCL_WRITE; ZCL_IDENTIFY; ZCL_ON_OFF; xZTOOL_P1; xMT_TASK; xMT_SYS_FUNC; xMT_ZDO_FUNC; xLCD_SUPPORTED=DEBUG; xMT_UART_DEFAULT_OVERFLOW=FALSE
  ICC8051.CCIncludePath2: as above
configuration DemoEB-Pro (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: ZIGBEEPRO; BUILD_ALL_DEVICES; HOLD_AUTO_START; LCD_SUPPORTED; HAL_UART=FALSE
  group App
    ../Source/: AT_AF.c AT_AF.h AT_App.c AT_App.h AT_uart.c AT_uart.h AT_ZDO.c AT_ZDO.h OSAL_App.c
  group App/app_drivers
    ../Source/: AT_ds18b20.c AT_ds18b20.h AT_printf.c AT_printf.h AT_relay.c AT_relay.h AT_switch.c AT_switch.h
  group App/others
    ../Source/: AT_ONOFF_output.c AT_ONOFF_output.h SampleApp.c SampleApp.h zcl_samplelight.c zcl_samplelight.h zcl_samplelight_data.c
  group App/AT_ZCL specification
    ../Source/: AT_ZCL.c AT_ZCL.h AT_ZCL_ONOFF.c AT_ZCL_ONOFF.h AT_ZCL_ONOFF_data.c AT_ZCL_ONOFF_SWITCH.c AT_ZCL_ONOFF_SWITCH.h AT_ZCL_ONOFF_SWITCH_data.c AT_ZCL_temperature.c AT_ZCL_temperature.h AT_ZCL_temperature_data.c
  group HAL/Common
    ../../../../../Components/hal/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    ../../../../../COMPONENTS/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
    ../../../../../Components/hal/include/: hal_ccm.h
  group HAL/Target/CC2530EB/Config
    ../../../../../COMPONENTS/hal/target/CC2530EB/: hal_board_cfg.h
  group HAL/Target/CC2530EB/Drivers
    ../../../../../Components/hal/target/CC2530EB/: hal_adc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2530EB/Includes
    ../../../../../COMPONENTS/hal/target/CC2530EB/: hal_aes.h hal_mcu.h hal_types.h
    ../../../../../Components/hal/target/CC2530EB/: hal_dma.h
  group MAC/High Level
    ../../../../../Components/mac/high_level/: mac_cfg.c
    ../../../../../COMPONENTS/mac/HIGH_LEVEL/: mac_high_level.h mac_pib.h mac_spec.h
  group MAC/Include
    ../../../../../COMPONENTS/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../../../COMPONENTS/mac/LOW_LEVEL/srf04/: mac_assert.h mac_backoff_timer.h mac_low_level.h mac_rx.h mac_rx_onoff.h mac_tx.h
    ../../../../../Components/mac/low_level/srf04/: mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_low_level.c mac_radio.c mac_radio.h mac_rx.c mac_rx_onoff.c mac_sleep.c mac_sleep.h mac_tx.c
  group MAC/Low Level/System
    ../../../../../Components/mac/low_level/srf04/single_chip/: mac_csp_tx.c mac_mcu.c mac_mem.c mac_radio_defs.c mac_rffrontend.c
    ../../../../../COMPONENTS/mac/LOW_LEVEL/srf04/SINGLE_CHIP/: mac_csp_tx.h mac_mcu.h mac_mem.h mac_radio_defs.h
  group MT
    ../../../../../Components/mt/: DebugTrace.c MT.c MT_AF.c MT_AF.h MT_APP.c MT_APP.h MT_DEBUG.c MT_DEBUG.h MT_NWK.c MT_NWK.h MT_SAPI.c MT_SAPI.h MT_SYS.c MT_TASK.c MT_TASK.h MT_UART.c mt_uart.h MT_UTIL.c MT_UTIL.h MT_VERSION.c MT_VERSION.h MT_ZDO.c MT_ZDO.h
    ../../../../../COMPONENTS/mt/: DebugTrace.h MT.h MT_RPC.h MT_SYS.h
  group NWK
    ../../../../../COMPONENTS/stack/nwk/: AddrMgr.h APS.h aps_frag.h aps_groups.h APSMEDE.h AssocList.h BindingTable.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.h nwk_util.h reflecttrack.h rtg.h
    ../../../../../Components/stack/nwk/: aps_util.h nwk_globals.c
    ../../../../../Components/stack/sys/: ZGlobals.c
    ../../../../../COMPONENTS/stack/sys/: ZGlobals.h
  group NWK/OSAL
    ../../../../../COMPONENTS/osal/include/: comdef.h OSAL.h OSAL_Clock.h OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
    ../../../../../Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../../Components/osal/mcu/cc2530/: OSAL_Nv.c
  group Profile
    ../../../../../Components/stack/af/: AF.c
    ../../../../../COMPONENTS/stack/af/: AF.h
    ../../../../../Components/stack/zcl/: zcl.c zcl_closures.c zcl_general.c zcl_hvac.c zcl_hvac.h zcl_lighting.c zcl_lighting.h zcl_ms.c zcl_ms.h zcl_pi.c zcl_pi.h zcl_se.c zcl_se.h zcl_ss.c zcl_ss.h
    ../../../../../COMPONENTS/stack/zcl/: zcl.h zcl_closures.h zcl_general.h
    ../Source/: zcl_ha.c zcl_ha.h
  group Security
    ../../../../../COMPONENTS/stack/sec/: ssp.h ssp_hash.h
  group Services
    ../../../../../Components/services/saddr/: saddr.c
    ../../../../../COMPONENTS/services/saddr/: saddr.h
  group Tools
    ../../../Tools/CC2530DB/: f8w2530.xcl f8wConfig.cfg f8wCoord.cfg f8wEndev.cfg f8wRouter.cfg
  group ZDO
    ../../../../../Components/stack/zdo/: ZDApp.c ZDConfig.c ZDNwkMgr.c ZDObject.c ZDObject.h ZDProfile.c ZDSecMgr.c ZDSecMgr.h
    ../../../../../COMPONENTS/stack/zdo/: ZDApp.h ZDConfig.h ZDNwkMgr.h ZDProfile.h
  group ZMac
    ../../../../../Components/zmac/f8w/: zmac.c zmac_cb.c
    ../../../../../COMPONENTS/zmac/: ZMAC.h
    ../../../../../COMPONENTS/zmac/f8w/: zmac_internal.h
  group ZMain
    ../../../ZMain/TI2530DB/: chipcon_cstartup.s51 OnBoard.c OnBoard.h ZMain.c
